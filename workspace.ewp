# IAR project workspace.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: E:\D\Semester fall 2022\Embedded\Lab tasks\tivaware
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: workspace.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: E:\D\Semester fall 2022\Embedded\Lab tasks\tivaware\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    asw/: CDD_SWC_1.c Decision_SWC.c Read_Data_SWC.c
    bsw/: Dio.c Dio.h Dio_Cfg.h Dio_LCfg.c Dio_LCfg.h Dio_Types.h port.c port.h Port_Cfg.h Port_LCfg.c Port_LCfg.h Port_Types.h
    ./: init.c init.h macros.h main.c startup_ewarm.c tm4c123gh6pm.h
    rte/: Rte.c Rte.h Rte_CDD_SWC_1.h Rte_Decision_SWC.h Rte_Read_Data_SWC.h Rte_Type.h Std_Types.h
